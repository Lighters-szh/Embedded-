# Keil uVision project wifi_mcusdk_dev_stm32_v3.0.uvprojx, settings and files
target wifi_mcusdk_dev_stm32_v3.0 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: wifi_mcusdk_dev_stm32_v3.0 +hex
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\..\User;..\..\User\hard;..\..\User\mcu_sdk;..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x\startup;..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\Libraries\CMSIS\CM3\CoreSupport
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
    ../../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
  group Libraries
    ../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c
  group Hard
    ../../User/hard/: Hal_Key.c Hal_RGB.c
  group mcu_sdk
    ../../User/mcu_sdk/: mcu_api.c protocol.c system.c
  group User
    ../../User/: main.c stm32f10x_it.c User_Flash.c User_Timer.c User_Uart.c
software components: CMSIS:CORE 5.0.1
